# IAR project esb_low_power_prx_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10040; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; ESB_PRESENT; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\proprietary_rf\esb; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: esb_low_power_prx_pca10040.hex
  ILINK.IlinkOutputFile: esb_low_power_prx_pca10040.out
  ILINK.IlinkIcfFile: esb_low_power_prx_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/experimental_log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group None
    ../../../../../../modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_Properitary_RF
    ../../../../../../components/proprietary_rf/esb/: nrf_esb.c
